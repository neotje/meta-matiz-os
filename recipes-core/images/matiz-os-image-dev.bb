require matiz-os-image.bb

IMAGE_FEATURES:append = " dev-pkgs"